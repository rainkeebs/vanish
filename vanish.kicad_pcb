# Repository rainkeebs/vanish

## KiCad design vanish.kicad_pcb

Parts:
C1, C2: 22pF; C_0805_2012Metric
C3: 1uF; C_0805_2012Metric
C4, C5, C6, C8: 0.1uF; C_0805_2012Metric
C7: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D41, D43, D44, D45: D_Small; D_SOD-123
F1: Polyfuse_Small; Fuse_1206_3216Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX38, MX39, MX46, MX47: MX-NoLED; MX-1U-NoLED
MX12, MX25: MX-NoLED; MX-1.75U-NoLED
MX13, MX37, MX44: MX-NoLED; MX-1.25U-NoLED
MX24: MX-NoLED; MX-1.5U-NoLED
MX42: MX-NoLED; MX-6.25U-ReversedStabilizers-NoLED
MX48: MX-NoLED; MX-2U-NoLED
R1, R4: 10k; R_0805_2012Metric
R2, R3: 22; R_0805_2012Metric
R5, R6: 5k1; R_0805_2012Metric
SW1: SW_Push; tht-reset
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
0: MX1.1 (COL), MX13.1 (COL), MX25.1 (COL), MX37.1 (COL), U1.25 (PD4)
1: MX2.1 (COL), MX14.1 (COL), MX26.1 (COL), MX38.1 (COL), U1.26 (PD6)
2: MX3.1 (COL), MX15.1 (COL), MX27.1 (COL), MX39.1 (COL), U1.27 (PD7)
3: MX4.1 (COL), MX16.1 (COL), MX28.1 (COL), U1.28 (PB4)
4: MX5.1 (COL), MX17.1 (COL), MX29.1 (COL), U1.29 (PB5)
5: MX6.1 (COL), MX18.1 (COL), MX30.1 (COL), MX42.1 (COL), U1.30 (PB6)
6: MX7.1 (COL), MX19.1 (COL), MX31.1 (COL), U1.20 (PD2)
7: MX8.1 (COL), MX20.1 (COL), MX32.1 (COL), U1.21 (PD3)
8: MX9.1 (COL), MX21.1 (COL), MX33.1 (COL), U1.22 (PD5)
9: MX10.1 (COL), MX22.1 (COL), MX34.1 (COL), MX44.1 (COL), U1.36 (PF7)
10: MX11.1 (COL), MX23.1 (COL), MX35.1 (COL), MX46.1 (COL), MX48.1 (COL), U1.37 (PF6)
11: MX12.1 (COL), MX24.1 (COL), MX36.1 (COL), MX47.1 (COL), U1.38 (PF5)
+5V: C4.1, C5.1, C6.1, C7.1, C8.1, F1.1, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
A: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.32 (PC7)
B: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.31 (PC6)
C: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.19 (PD1)
D: D37.1 (K), D38.1 (K), D39.1 (K), D41.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), U1.18 (PD0)
D+: R2.2; also elsewhere on the board
D-: R3.2; also elsewhere on the board
DP+: R2.1, U1.4 (D+)
DP-: R3.1, U1.3 (D-)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, R4.1, R5.2, R6.2, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), Y1.2; also elsewhere on the board
unnamed: C3.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW), MX48.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D41.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX44.2 (ROW)
unnamed: D44.2 (A), MX46.2 (ROW)
unnamed: D45.2 (A), MX47.2 (ROW)
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R4.2, U1.33 (~HWB~/PE2)
unnamed 68: R5.1; also elsewhere on the board
unnamed 69: R6.1; also elsewhere on the board
unnamed: C2.2, U1.16 (XTAL2), Y1.3
VCC: F1.2; also elsewhere on the board

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
Board: 2 copper layers, 243.4 x 76.2 mm, 114 parts (63 on the bottom side), 74 nets.

Other parts of the board:
H1, H2, H3, H4, H5, H6, H7: Hole; M2_HOLE_v3
R7: 1M; R_0805_2012Metric
U2: SRV05-4; SOT-23-6
USB1: HRO-TYPE-C-31-M-12

Their connections:
D+: U2.3, U2.6, USB1.6, USB1.8; also elsewhere on the board
D-: U2.1, U2.4, USB1.5, USB1.7; also elsewhere on the board
GND: R7.2, U2.2, USB1.1, USB1.12; also elsewhere on the board
unnamed 68: USB1.4; also elsewhere on the board
unnamed 69: USB1.10; also elsewhere on the board
VCC: U2.5, USB1.2, USB1.11; also elsewhere on the board

## Commit log

2020-11-08 initial
2020-11-09 pcb woirk
2020-11-15 done
